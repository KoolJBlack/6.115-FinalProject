# Keil uVision project RS232_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: RS232_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h LCD.c LCD.h LCD_PM.c LCD_LCDPort_aliases.h LCD_LCDPort.c LCD_LCDPort.h UART.c UART.h UART_PM.c UART_INT.c tx_int.c tx_int.h rx_int.c rx_int.h TX_aliases.h TX.c TX.h ADC_In_aliases.h ADC_In.c ADC_In.h PGA_1.c PGA_1.h PGA_1_PM.c ADC_SAR_1.c ADC_SAR_1.h ADC_SAR_1_INT.c ADC_SAR_1_PM.c ADC_SAR_1_theACLK.c ADC_SAR_1_theACLK.h ADC_SAR_1_Bypass_aliases.h ADC_SAR_1_Bypass.c ADC_SAR_1_Bypass.h VDAC8_1.c VDAC8_1.h VDAC8_1_PM.c Clock_1.c Clock_1.h FFT_ISR.c FFT_ISR.h Clock_2.c Clock_2.h Clock_ISR.c Clock_ISR.h UART_Amulet.c UART_Amulet.h UART_Amulet_PM.c UART_Amulet_INT.c rx_int_Amulet.c rx_int_Amulet.h TX_Amulet_aliases.h TX_Amulet.c TX_Amulet.h
target Release (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: as above
  output: RS232_PSoC5lib (library)
